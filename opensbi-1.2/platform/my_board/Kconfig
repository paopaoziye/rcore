## opensbi-1.2/platform/my_board/Kconfig
```kconfig
# 启用FDT、FDT域和FDT的PMU支持
config PLATFORM_GENERIC
	bool
	select FDT
	select FDT_DOMAIN
	select FDT_PMU
	default y
```
